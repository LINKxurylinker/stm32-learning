# Keil uVision project Base.uvprojx, settings and files
target Base (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Base +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,ARM_MATH_CM4
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\CORE;..\STM32F4xx_DSP_Support;..\HARDWARE\TOUCH;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\HARDWARE\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TOUCH/: touch.c touch.h gt9147.c gt9147.h ctiic.h ctiic.c ott2001a.c ott2001a.h
    ../HARDWARE/24CXX/: 24cxx.h 24cxx.c
    ../HARDWARE/IIC/: myiic.c myiic.h
    ../HARDWARE/KEY/: key.c key.h
    ./: adc.h adc.c measure.h measure.c cmd.h cmd.c ui.h ui.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group DSP
    ../STM32F4xx_DSP_Support/: arm_cortexM4lf_math.lib arm_math.h arm_common_tables.h arm_const_structs.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_dma.c
    ../FWLIB/inc/: stm32f4xx_tim.h
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
