# Keil uVision project PWM_UI_Framework.uvprojx, settings and files
target PWM_UI_Framework (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM_UI_Framework +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\tftlcd;..\HARDWARE\touch;..\HARDWARE\24Cxx;..\HARDWARE\iic;..\HARDWARE\mpu6050;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: usart.c usart.h
  group HARDWARE
    ../HARDWARE/tftlcd/: tftlcd.c font.H tftlcd.h
    ../HARDWARE/touch/: touch.c touch.h
    ../HARDWARE/24Cxx/: 24cxx.c
    ../HARDWARE/iic/: iic.c iic.h
    ../HARDWARE/mpu6050/: mpu6050.c mpu6050.h
  group APP
    ../APP/: app_boot.c ui_hanzi.c ui_hanzi.h app_main.c app_maze.c app_snake.c app_stopwatch.c app_sweep.c bsp_capture.c bsp_pwm.c bsp_spwm.c bsp_tick.c ui_core.c ui_pages.c app_config.h app_main.h app_maze.h app_snake.h app_stopwatch.h app_sweep.h bsp_capture.h bsp_pwm.h bsp_spwm.h bsp_tick.h ui_core.h ui_pages.h
